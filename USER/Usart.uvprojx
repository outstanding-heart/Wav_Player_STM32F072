# Keil uVision project Usart.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F072CB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: Usart +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,USE_STM320518_EVAL,STM320518_EVAL_REVB
  c include: ..\SYTSTEM\Libraries\CMSIS\Include;..\SYTSTEM\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\SYTSTEM\Libraries\STM32F0xx_CPAL_Driver\inc;..\SYTSTEM\Utilities\STM32_EVAL;..\SYTSTEM\Utilities\STM32_EVAL\Common;..\SYTSTEM\Utilities\STM32_EVAL\STM320518_EVAL;..\SYTSTEM\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\SYTSTEM\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ./: main.c usart1.c dac1.c flash.c wav.c
  group DRIVER
    ../SYTSTEM/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group EVAL
    ../SYTSTEM/Utilities/STM32_EVAL/STM320518_EVAL/: stm320518_eval.c
  group ::Device
    RTE/Device/STM32F072CB/: startup_stm32f072.s system_stm32f0xx.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.5.0
